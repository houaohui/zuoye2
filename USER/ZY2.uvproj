# Keil uVision project ZY2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ZY2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FUN
  group USER
    ./: STARTUP.A51 main.c 程序说明
  group FUN
    ../FUN/: lcd1602.c key.c IRReceived.c d18b20.c led.c EEROM.c
